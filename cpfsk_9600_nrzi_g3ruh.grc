options:
  parameters:
    generate_options: qt_gui
    id: cpfsk_9600_nrzi_g3ruh
    output_language: python
    title: CPFSK 9.6 kbps NRZI + G3RUH Descrambler
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: NRZ-I bit rate; binary CPFSK symbol rate
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol at Symbol Sync input
    value: samp_rate/symbol_rate
  states: {}
- name: f_mid
  id: variable
  parameters:
    comment: Measured CPFSK tone-pair center offset in Hz
    value: '12121'
  states: {}
- name: f_dev
  id: variable
  parameters:
    comment: Measured deviation from tone-pair center in Hz
    value: '3525'
  states: {}
- name: qdemod_gain
  id: variable
  parameters:
    comment: Normalize discriminator levels to approximately +/-1
    value: samp_rate/(2*math.pi*f_dev)
  states: {}
- name: dc_norm
  id: variable
  parameters:
    comment: Remove measured frequency-center offset after normalized discriminator
    value: '-f_mid/f_dev'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: qdemod_gain
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Fixed removal of the measured +12.121 kHz center offset
    const: dc_norm
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: C:\Users\nzlcn\gnuradio\decoded_bits_g3ruh.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\nzlcn\gnuradio\intern_Rec.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: Capture-specific alignment; first valid HDLC flag starts at bit 31
    num_items: '31'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_NRZI
    comment: Decode NRZ-I line symbols before byte packing
    modulus: '2'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    comment: 'G3RUH multiplicative descrambler: polynomial 1 + x^12 + x^17'
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: 60-sample moving-average matched filter for demodulated CPFSK symbols
    decim: '1'
    taps: '[1.0/int(sps)]*int(sps)'
    type: fff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.2'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '160'
    comment: Two narrow peaks near -1 and +1 indicate correct timing
    grid: 'True'
    label1: '"Symbol Sync soft decisions"'
    name: '"Symbol Sync Level Histogram"'
    size: '16384'
    type: float
    xmax: '1.3'
    xmin: '-1.3'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: symbol_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_descrambler_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_float_to_complex_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
